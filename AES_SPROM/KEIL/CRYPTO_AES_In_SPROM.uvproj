# Keil uVision project CRYPTO_AES_In_SPROM.uvproj, settings and files
target CRYPTO_AES_In_SPROM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: CRYPTO_AES_In_SPROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Library\Device\Nuvoton\M480\Include;..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M480\Source\ARM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\CRYPTO_AES_In_SPROM.sct
  link misc: --map  --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group User
    ../: main.c sprom.c
  group Library
    ../../Library/StdDriver/src/: retarget.c clk.c crypto.c fmc.c sys.c uart.c
